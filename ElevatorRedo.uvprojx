# Keil uVision project ElevatorRedo.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.2
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: ElevatorRedo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ./: core_cm4_constants.s main.s startup_stm32l476xx.s stm32l476xx_constants.s SysClock.c SysClock.h UART.c UART.h hexUpdate.s lightUpdate.s Parse.s Floors.s Floor4.s Floor3.s Floor2.s Floor1.s MotorUp.s MotorDown.s keypadScan.s DoorOpen.s DoorClose.s
software components: CMSIS:CORE 5.6.0
